options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: micgain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.1'
    stop: '10'
    value: '300e-3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 30e3
    quad_rate: 4*samp_rate
    tau: '75e-6'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: micgain
    type: float
  states: {}
- name: osmosdr_sink_1
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: '50'
    freq0: 103e6
    gain0: '50'
    if_gain0: '50'
    sample_rate: 256*samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 16*samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Waterfall Plot"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: 4*samp_rate
    interp: 256*samp_rate
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_wfm_tx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_1, '0']

metadata:
  file_format: 1
